## sdkconfig.defaults
```kconfig
CONFIG_ESP_WIFI_NVS_ENABLED=n
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_PARTITION_TABLE_SINGLE_APP_LARGE=y
```
